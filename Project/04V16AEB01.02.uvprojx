# Keil uVision project 04V16AEB01.02.uvprojx, settings and files
target ISO_LED (ARM-ADS)
  device: STM32F042K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 04V16AEB01.02 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F042,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\include;..\Libraries\CMSIS\source\startup;..\Libraries\FWLib\inc;..\User\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --libpath=C:\Keil_v5\ARM\ARMCC\lib
  group StartUp
    ../Libraries/CMSIS/source/startup/arm/: startup_stm32f042.s
  group CMSIS
    ../Libraries/CMSIS/source/: system_stm32f0xx.c
  group FWLib
    ../Libraries/FWLib/src/: stm32f0xx_rcc.c stm32f0xx_gpio.c stm32f0xx_can.c stm32f0xx_misc.c stm32f0xx_flash.c stm32f0xx_iwdg.c
  group User
    ../User/src/: iso_led.c iso_main.c iso_can.c stm32f0xx_it.c i2c.c IO.C timer.c display.C
